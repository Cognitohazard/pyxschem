v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/nmos.sym} 200 -100 0 0 {name=M1
model=nfet_01v8
W=1
L=0.15
nf=1}
N 200 -140 200 -200 {lab=drain}
