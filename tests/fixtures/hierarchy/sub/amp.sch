v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {nmos.sym} 200 -100 0 0 {name=M1 model=nfet w=1u l=0.15u}
C {sub/bias.sch} 400 -100 0 0 {name=X2}
N 200 -130 400 -130 {}
