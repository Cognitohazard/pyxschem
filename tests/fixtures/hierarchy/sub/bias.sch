v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {nmos.sym} 200 -100 0 0 {name=M3 model=nfet w=2u l=0.15u}
N 200 -130 200 -200 {}
